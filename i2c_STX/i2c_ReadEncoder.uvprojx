# Keil uVision project i2c_ReadEncoder.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: i2c_ReadEncoder
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\;.\Src;.\Inc;.\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;,\STM32F10x_StdPeriph_Driver\src;.\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./: startup_stm32f10x_md.s
  group user
    ./Src/: i2c_STX.c main.c read_encoder.c
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group cmsis
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
  group stdperiph
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_exti.c
